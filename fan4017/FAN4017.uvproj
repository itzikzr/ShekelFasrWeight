# Keil uVision project FAN4017.uvproj, settings and files
target Target 1 (MCS-51)
  device: 80C32 Intel
  cpu: IRAM(0-0xFF) CLOCK(24000000)
  output: FAN4017 +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: ATOD.C CALIB.C CALIBZ.C CONSOLE.C Counting.c DATA.C HIDEMODE.C MAIN.C net.c NOVRAM.C POWER.C PRINT.C PROGMODE.C relsys.c RTC.C SERIAL.C STARTUP.C TESTMODE.C UART.C WEIGHT.C AFUN.ASM RUNTIME.ASM Cal420.c
